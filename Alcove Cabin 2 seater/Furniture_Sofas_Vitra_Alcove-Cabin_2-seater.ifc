Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-05-18T18:16:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 18 18:16:58 2021 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{952A9F74-46FF-412E-83DD-6FE53DB115B0}\ifc * Database version: 5507 * Database creation date: Tue May 18 18:16:57 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 18 18:16:57 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 18 18:16:57 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Alcove Cabin 2 seater, Furniture_Sofas_Vitra_Alcove-Cabin_2-seater:Alcove Cabin 2 seater:437631
In: Level 1
Type - Material: Textile laser yellow pastel green 23, 01 chrome
Type - Dimensions - NominalDepth: 1620 mm; NominalLength: 2370 mm
Type - General - Author: BIMStone; BIMObjectName: Furniture_Sofas_Vitra_Alcove-Cabin_2-seater; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_12_81; Uniclass2015Description: Sofas; Uniclass2015Reference: Pr_40_50_12_81; Version: 1; VersionDate: 17/05/2021
Type - Identity Data - Collection: Alcove Cabin; Cost: 0; Designer: Ronan & Erwan Bouroullec; Manufacturer: Vitra; Model: Alcove Cabin 2 seater; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; Type Name: Alcove Cabin 2 seater
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Sofas_Vitra_Alcove-Cabin_2-seater; Features: n/a; Finish: Structural frame: tubular steel, chrome-plated or powder-coated (smooth); metal frame with upholstery webbing (lounge upholstery) or MDF base board (work upholstery). Body: back and side panels with integrated MDF boards for structural support, panel sections connected with zip fasteners. Upholstery/seat: polyurethane foam and polyester fibre. Alcove sofas come in two different upholstery versions: soft 'lounge upholstery' for relaxed sitting and firmer 'work upholstery' for work-oriented sitting with various seat heights. Lounge upholstery = 485 mm (measured according to EN 1335-1 = 325 mm), work upholstery = 480 mm (measured according to EN 1335-1 = 385 mm). Covers: removable. Back cushions and cushion set: polyurethane chips and microfibre filling. The cushion set is sold separately. Legs: tubular steel, chrome-plated or powder-coated (smooth). Alcove Love Seat: incl. 1 back cushion. Cushion set for Love Seat: 2 armrest cushions and 1 small back cushion; Grade: n/a; Material: Polyurethane foam, polyester fibre, steel & MDF; ModelNumber: n/a; ModelReference: n/a; Name: Alcove-Cabin_2-seater; ReplacementCost: n/a; Shape: Sculptured; Size: 2370x1620x985/1367 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - Back: no; BaseOn: no; MetaProperties_Back: Lowback; MetaProperties_BaseOn: Glides; MetaProperties_TableTopVersion: Table top not included; Table: no; TableVersion: no
Dimensions - Area: 7.76955 m2; NominalHeight: 985 mm; Volume: 3.78181 m3
Materials and Finishes - CoverMaterial: Textile laser yellow pastel green 23; FrameMaterial: 01 chrome; PortFinishMaterial: Port finish powder coating basic dark; TableTopMaterial: Table light oak
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Furniture_Sofas_Vitra_Alcove-Cabin_2-seater: Alcove Cabin 2 seater; Family and Type: Furniture_Sofas_Vitra_Alcove-Cabin_2-seater: Alcove Cabin 2 seater; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Sofas_Vitra_Alcove-Cabin_2-seater: Alcove Cabin 2 seater; Type Id: Furniture_Sofas_Vitra_Alcove-Cabin_2-seater: Alcove Cabin 2 seater; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
